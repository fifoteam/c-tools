# Keil uVision project MCU123_LPC1114_Kit.uvproj, settings and files
target System (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MCU123_LPC1114_Kit
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Source\Base;..\..\..\Source\Driver\NXP\LPC1114_302\Core\M0;..\..\..\Source\Driver\NXP\LPC1114_302\Core\System_Control_Block;..\..\..\Source\Driver\NXP\LPC1114_302\Core\System_Timer;..\..\..\Source\Driver\NXP\LPC1114_302\Core\NVIC;..\..\..\Source\Driver\NXP\LPC1114_302\Core\System_Configuration;..\..\..\Source\Driver\NXP\LPC1114_302\Core\IO_Configuration;..\..\..\Source\Driver\NXP\LPC1114_302\GPIO;..\..\..\Source\Driver\NXP\LPC1114_302\Counter_Timer_16_Bit;..\..\..\Source\Driver\NXP\LPC1114_302\UART;..\..\..\Source\Driver\NXP\LPC1114_302\IIC;..\..\..\Source\Driver\NXP\LPC1114_302\ADC;..\..\..\Source\Library\MCU123\LPC1114_Kit\Core;..\..\..\Source\Library\MCU123\LPC1114_Kit\GPIO;..\..\..\Source\Library\MCU123\LPC1114_Kit\Counter_Timer_16_Bit;..\..\..\Source\Library\MCU123\LPC1114_Kit\UART;..\..\..\Source\Library\MCU123\LPC1114_Kit\IIC;..\..\..\Source\Library\MCU123\LPC1114_Kit\ADC;..\..\..\Source\Application\MCU123\LPC1114_Kit\Idle;..\..\..\Source\Application\MCU123\LPC1114_Kit\LED;..\..\..\Source\Application\MCU123\LPC1114_Kit\Buzzer;..\..\..\Source\Application\MCU123\LPC1114_Kit\Serial;..\..\..\Source\Application\MCU123\LPC1114_Kit\Temperature_EEPROM;..\..\..\Source\Application\MCU123\LPC1114_Kit\Resistor
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\Scatter\MCU123_LPC1114_Kit_Release.sct
  group Base
    ../../../Source/Base/: Base.c
  group Driver
    ../../../Source/Driver/NXP/LPC1114_302/Core/M0/: NXP_LPC1114_302_M0_Context.s NXP_LPC1114_302_M0_Exception.c NXP_LPC1114_302_M0_Schedule.c
    ../../../Source/Driver/NXP/LPC1114_302/Core/System_Control_Block/: NXP_LPC1114_302_System_Control_Block.c
    ../../../Source/Driver/NXP/LPC1114_302/Core/System_Timer/: NXP_LPC1114_302_System_Timer.c
    ../../../Source/Driver/NXP/LPC1114_302/Core/NVIC/: NXP_LPC1114_302_NVIC.c
    ../../../Source/Driver/NXP/LPC1114_302/Core/System_Configuration/: NXP_LPC1114_302_System_Configuration.c
    ../../../Source/Driver/NXP/LPC1114_302/Core/IO_Configuration/: NXP_LPC1114_302_IO_Configuration.c
    ../../../Source/Driver/NXP/LPC1114_302/GPIO/: NXP_LPC1114_302_GPIO.c
    ../../../Source/Driver/NXP/LPC1114_302/Counter_Timer_16_Bit/: NXP_LPC1114_302_Counter_Timer_16_Bit.c
    ../../../Source/Driver/NXP/LPC1114_302/UART/: NXP_LPC1114_302_UART.c
    ../../../Source/Driver/NXP/LPC1114_302/IIC/: NXP_LPC1114_302_IIC.c
    ../../../Source/Driver/NXP/LPC1114_302/ADC/: NXP_LPC1114_302_ADC.c
  group Library
    ../../../Source/Library/MCU123/LPC1114_Kit/Core/: MCU123_LPC1114_Kit_Core.c
    ../../../Source/Library/MCU123/LPC1114_Kit/GPIO/: MCU123_LPC1114_Kit_GPIO.c
    ../../../Source/Library/MCU123/LPC1114_Kit/Counter_Timer_16_Bit/: MCU123_LPC1114_Kit_Counter_Timer_16_Bit.c
    ../../../Source/Library/MCU123/LPC1114_Kit/UART/: MCU123_LPC1114_Kit_UART.c
    ../../../Source/Library/MCU123/LPC1114_Kit/IIC/: MCU123_LPC1114_Kit_IIC.c
    ../../../Source/Library/MCU123/LPC1114_Kit/ADC/: MCU123_LPC1114_Kit_ADC.c
  group Application
    ../../../Source/Application/MCU123/LPC1114_Kit/Idle/: MCU123_LPC1114_Kit_Idle.c
    ../../../Source/Application/MCU123/LPC1114_Kit/LED/: MCU123_LPC1114_Kit_LED.c
    ../../../Source/Application/MCU123/LPC1114_Kit/Buzzer/: MCU123_LPC1114_Kit_Buzzer.c
    ../../../Source/Application/MCU123/LPC1114_Kit/Serial/: MCU123_LPC1114_Kit_Serial.c
    ../../../Source/Application/MCU123/LPC1114_Kit/Temperature_EEPROM/: MCU123_LPC1114_Kit_Temperature_EEPROM.c
    ../../../Source/Application/MCU123/LPC1114_Kit/Resistor/: MCU123_LPC1114_Kit_Resistor.c
    ../../../Source/Application/MCU123/LPC1114_Kit/Main/: MCU123_LPC1114_Kit_Main.c
